/* ScummVM - Graphic Adventure Engine
 *
 * ScummVM is the legal property of its developers, whose names
 * are too numerous to list here. Please refer to the COPYRIGHT
 * file distributed with this source distribution.
 *
 * This program is free software: you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation, either version 3 of the License, or
 * (at your option) any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 *
 */

#include "ultima/ultima1/views/interactions/dead.h"
#include "ultima/ultima1/ultima1.h"

namespace Ultima {
namespace Ultima1 {
namespace Views {
namespace Interactions {

// Frames to pause before the resurrection count-up starts, and between each
// point of hits/food animated back afterward - approximates the original's
// timer-tick based wait(80) and wait(1) calls
constexpr int INTRO_DELAY = 80;
constexpr int COUNT_DELAY = 1;

// Hits/food the player is resurrected with
constexpr int RESURRECTED_AMOUNT = 99;

constexpr int EDGE_COLOR = 15;

// The skull glyph shown while the player is dead - a 64x95 1-bit-per-pixel
// bitmap, stored as 95 rows of 4 big-endian 16-bit words (bit 15 = leftmost
// pixel of the word), matching the original's drawDeathGraphic byte table
constexpr int DEATH_GRAPHIC_WIDTH = 64;
constexpr int DEATH_GRAPHIC_HEIGHT = 95;

// Absolute screen position the original centers the glyph at within the
// map viewport, converted below to be local to this view's own bounds
constexpr int DEATH_GRAPHIC_SCREEN_X = 128;
constexpr int DEATH_GRAPHIC_SCREEN_Y = 31;

static const uint8 DEATH_GRAPHIC_DATA[DEATH_GRAPHIC_HEIGHT * 8] = {
	0x00, 0x00, 0x3f, 0x00, 0x00, 0xfc, 0x00, 0x00, 0x00, 0x00, 0xff, 0x01, 0x80, 0xff, 0x00, 0x00,
	0x00, 0x00, 0xff, 0x07, 0xe0, 0xff, 0x00, 0x00, 0x00, 0x00, 0xff, 0x3f, 0xfc, 0xff, 0x00, 0x00,
	0x00, 0x00, 0xff, 0xff, 0xfe, 0xff, 0x00, 0x00, 0x03, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0x80,
	0x07, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0xe0, 0x1f, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0xf8,
	0x1f, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0xfc, 0x7f, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0xfe,
	0x7f, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0xff, 0xff, 0x00, 0xff, 0xff, 0xff, 0xff, 0x80, 0xff,
	0xff, 0x01, 0xff, 0xff, 0xff, 0xff, 0x80, 0xff, 0xff, 0x03, 0xff, 0xff, 0xff, 0xff, 0xe0, 0xff,
	0xff, 0x07, 0xff, 0xff, 0xff, 0xff, 0xf0, 0xff, 0xff, 0x07, 0xff, 0xff, 0xff, 0xff, 0xf0, 0xff,
	0xff, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xf0, 0xff, 0xff, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xfc, 0xff,
	0xff, 0x1f, 0xff, 0xff, 0xff, 0xff, 0xfc, 0xff, 0xff, 0x1f, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff,
	0xff, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff,
	0xff, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff,
	0xff, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
	0xff, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
	0xff, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
	0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff,
	0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe3, 0xff, 0xfe, 0xff,
	0xff, 0xff, 0xff, 0xc3, 0x80, 0xff, 0xfe, 0x0f, 0xfc, 0x7f, 0xff, 0x01, 0x00, 0xff, 0xfc, 0x03,
	0xf0, 0x7f, 0xff, 0x00, 0x00, 0xff, 0xfc, 0x03, 0xc0, 0x7f, 0xbf, 0x00, 0x00, 0xff, 0xfc, 0x00,
	0x80, 0x7f, 0x7f, 0x00, 0x00, 0xff, 0xfc, 0x00, 0x80, 0x7f, 0x7f, 0x00, 0x00, 0xfe, 0xfc, 0x00,
	0x80, 0x3f, 0x1f, 0x00, 0x00, 0xfe, 0xfc, 0x00, 0x00, 0x3f, 0x3f, 0x00, 0x00, 0xfe, 0xfc, 0x00,
	0x00, 0x3f, 0x3f, 0x00, 0x00, 0xfe, 0xfc, 0x00, 0x00, 0x3f, 0x3f, 0x00, 0x00, 0xfe, 0xfe, 0x00,
	0x00, 0x3f, 0x7f, 0x00, 0x00, 0xfe, 0xfe, 0x00, 0x00, 0x1f, 0xff, 0x00, 0x00, 0xff, 0xfe, 0x00,
	0x80, 0x1f, 0xff, 0x03, 0x80, 0xff, 0xfe, 0x01, 0x80, 0x1f, 0xff, 0x07, 0xc0, 0xff, 0xfe, 0x01,
	0x80, 0x1f, 0xfd, 0x0f, 0xf0, 0xbf, 0xfe, 0x01, 0xc0, 0x1f, 0xfc, 0x3f, 0xfc, 0x1f, 0xfe, 0x03,
	0xe0, 0x1f, 0xf8, 0x7f, 0xff, 0x1f, 0xfe, 0x07, 0xf0, 0x1f, 0xf0, 0xff, 0xff, 0x0f, 0xfe, 0xff,
	0xff, 0x1f, 0xf0, 0xff, 0xff, 0x0f, 0xfe, 0xff, 0xff, 0x1f, 0xe0, 0xff, 0xff, 0x07, 0xfe, 0xff,
	0xff, 0x1f, 0xe0, 0xff, 0xff, 0x07, 0xfe, 0xff, 0xff, 0x1f, 0xc0, 0xff, 0xff, 0x07, 0xfc, 0xff,
	0xff, 0x1f, 0xc0, 0xff, 0xff, 0x03, 0xfc, 0xff, 0xff, 0x1f, 0xc0, 0xff, 0xff, 0x03, 0xfc, 0xff,
	0xff, 0x0f, 0x80, 0xff, 0xff, 0x03, 0xf8, 0xff, 0xff, 0x0f, 0x80, 0xff, 0xff, 0x03, 0xf8, 0xff,
	0xff, 0x0f, 0xc0, 0xff, 0xff, 0x07, 0xf0, 0xff, 0xff, 0x07, 0xc5, 0xff, 0xff, 0x0f, 0xf0, 0xff,
	0xff, 0x03, 0xff, 0xff, 0xff, 0xff, 0xe0, 0xff, 0xff, 0x03, 0xff, 0xff, 0xff, 0xff, 0xc0, 0xfb,
	0xff, 0x01, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x7f, 0xff, 0x01, 0xff, 0xbf, 0xff, 0xff, 0x80, 0x0f,
	0xf6, 0x00, 0xff, 0x7f, 0xff, 0xff, 0x80, 0x8f, 0xfe, 0x00, 0xff, 0x7f, 0xff, 0xff, 0x00, 0x8f,
	0x7e, 0x00, 0xff, 0x7f, 0xff, 0xff, 0x00, 0x9f, 0x7e, 0x00, 0xff, 0x3f, 0xff, 0xff, 0x00, 0x9f,
	0x7e, 0x00, 0xff, 0x3f, 0xff, 0xff, 0x00, 0x9f, 0x3e, 0x00, 0xdf, 0x7f, 0xff, 0xff, 0x00, 0xbf,
	0x3f, 0x00, 0x7b, 0xff, 0xff, 0xcf, 0x00, 0xff, 0x3f, 0x00, 0x93, 0xda, 0xac, 0xc9, 0x00, 0xff,
	0x3f, 0x00, 0x90, 0x5a, 0x0d, 0x88, 0x00, 0x7f, 0x3f, 0x00, 0x90, 0xda, 0x2d, 0x88, 0x00, 0xff,
	0x3f, 0x00, 0x10, 0xff, 0xad, 0x88, 0x00, 0xfe, 0x1f, 0x00, 0xf0, 0xeb, 0xff, 0xbb, 0x00, 0xfe,
	0x1f, 0x00, 0x3f, 0xd7, 0x6f, 0xe6, 0x00, 0x7e, 0x1f, 0x00, 0x24, 0xd5, 0x6a, 0x92, 0x00, 0xfe,
	0x1f, 0x00, 0x24, 0xfd, 0x4b, 0xb2, 0x00, 0xfc, 0x0f, 0x00, 0x64, 0xff, 0x5f, 0xb6, 0x00, 0xfc,
	0x0f, 0x00, 0xfc, 0xff, 0x7f, 0xbe, 0x00, 0xf8, 0x07, 0x00, 0xff, 0xff, 0xff, 0x7b, 0x00, 0xf8,
	0x03, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0xf0, 0x03, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0xe0,
	0x01, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0xc0, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0x80,
	0x00, 0x00, 0xff, 0x7f, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0xff, 0x3f, 0xfe, 0xff, 0x00, 0x00,
	0x00, 0x00, 0xff, 0x1f, 0xfc, 0xff, 0x00, 0x00, 0x00, 0x00, 0xff, 0x07, 0xf0, 0xff, 0x00, 0x00,
	0x00, 0x00, 0xff, 0x01, 0xe0, 0xff, 0x00, 0x00, 0x00, 0x00, 0x7f, 0x00, 0x80, 0xff, 0x00, 0x00,
	0x00, 0x00, 0x0f, 0x00, 0x00, 0xfc, 0x00, 0x00
};

bool Dead::msgFocus(const FocusMessage &msg) {
	// Claim the map viewport area (inside the game border, which is left
	// drawn by whatever view was showing underneath)
	setBounds(Common::Rect(8, 8, 312, 152));

	auto &sg = _G(savegame);
	sg._food = 0;
	sg._hits = 0;
	sg._coins = 0;
	g_engine->findView("Stats")->draw();

	g_engine->playFX(2);
	g_engine->playFX(2);
	g_engine->playFX(2);

	writeString(sg._name);
	writeString(", thou art dead\n");

	_phase = PHASE_INTRO;
	_delayCtr = INTRO_DELAY;
	return true;
}

void Dead::draw() {
	auto s = getSurface();
	s.clear();

	drawDeathGraphic();
}

void Dead::drawDeathGraphic() {
	auto s = getSurface();

	// This view's own bounds start at absolute screen (8, 8), so convert
	// down to the local coordinates its surface uses
	int startX = DEATH_GRAPHIC_SCREEN_X - 8;
	int startY = DEATH_GRAPHIC_SCREEN_Y - 8;

	for (int row = 0; row < DEATH_GRAPHIC_HEIGHT; ++row) {
		const uint8 *rowData = &DEATH_GRAPHIC_DATA[row * 8];
		int x = startX;

		for (int wordIdx = 0; wordIdx < 4; ++wordIdx) {
			uint16 word = rowData[wordIdx * 2] | (rowData[wordIdx * 2 + 1] << 8);

			for (int bit = 15; bit >= 0; --bit, ++x) {
				if (word & (1 << bit))
					s.setPixel(x, startY + row, EDGE_COLOR);
			}
		}
	}
}

bool Dead::tick() {
	if (_delayCtr > 0 && --_delayCtr == 0) {
		auto &sg = _G(savegame);

		switch (_phase) {
		case PHASE_INTRO:
			writeString("Attempting resurrection!\n");
			_phase = PHASE_HITS;
			_delayCtr = COUNT_DELAY;
			break;

		case PHASE_HITS:
			++sg._hits;
			g_engine->findView("Stats")->draw();

			if (sg._hits >= RESURRECTED_AMOUNT) {
				for (int continent = 0; continent < 4; ++continent)
					removeCreaturesOnContinent(continent);
				_phase = PHASE_FOOD;
			}
			_delayCtr = COUNT_DELAY;
			break;

		case PHASE_FOOD:
			++sg._food;
			g_engine->findView("Stats")->draw();

			if (sg._food >= RESURRECTED_AMOUNT)
				finish();
			else
				_delayCtr = COUNT_DELAY;
			break;
		}
	}

	return Interaction::tick();
}

void Dead::removeCreaturesOnContinent(int continent) {
	for (int index = 1; index < _G(overworldEntityCount); ++index) {
		auto &e = _G(savegame)._overworldEntities[index];

		if (_G(map).getContinentAt(e._x, e._y) == continent) {
			_G(savegame).removeOverworldCreatureAt(e._x, e._y);
			--_G(creaturesCount);
		}
	}
}

void Dead::resetPlayerPosition() {
	auto &sg = _G(savegame);
	int origContinent = _G(map).getContinentAt(sg._overworldPos);
	int x = 0, y = 0, tile = 0;
	bool found = false;

	while (!found) {
		x = sg._overworldPos.x + g_engine->getRandomNumber(3, 23) - 13;
		y = sg._overworldPos.y + g_engine->getRandomNumber(3, 23) - 13;

		if (x < 2 || x > Data::OVERWORLD_WIDTH - 3)
			x = sg._overworldPos.x;
		if (y < 2 || y > Data::OVERWORLD_HEIGHT - 3)
			y = sg._overworldPos.y;

		if (_G(map).getContinentAt(x, y) != origContinent)
			continue;

		tile = _G(map).getTileAt(x, y);
		found = tile == Data::TILE_GRASS || tile == Data::TILE_WOODS;
	}

	sg._overworldPos = Common::Point(x, y);

	auto &e = sg._overworldEntities[0];
	e._type = Data::TILE_PLAYER;
	e._data = tile;
	e._x = x;
	e._y = y;
}

void Dead::finish() {
	auto &sg = _G(savegame);

	// Losing any ridden transport
	if (sg._transportType != Data::TRANSPORT_FOOT) {
		--sg._transports[sg._transportType];
		sg._transportType = Data::TRANSPORT_FOOT;
		sg._overworldEntities[0]._type = Data::TILE_PLAYER;
	}

	// All weapons are lost, and everything readied is unreadied
	for (int i = 0; i < Data::WEAPON_COUNT; ++i)
		sg._weapons[i] = 0;
	sg._equippedWeapon = Data::WEAPON_NONE;
	sg._equippedArmor = Data::ARMOR_NONE;
	sg._equippedSpell = Data::SPELL_PRAYER;

	g_engine->playFX(5);
	resetPlayerPosition();

	_G(map).load(Data::MAP_OVERWORLD);
}

} // namespace Interactions
} // namespace Views
} // namespace Ultima1
} // namespace Ultima
