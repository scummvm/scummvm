/* ScummVM - Graphic Adventure Engine
 *
 * ScummVM is the legal property of its developers, whose names
 * are too numerous to list here. Please refer to the COPYRIGHT
 * file distributed with this source distribution.
 *
 * This program is free software: you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation, either version 3 of the License, or
 * (at your option) any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 *
 */

#include "common/util.h"
#include "ultima/ultima3/gfx/dungeon_view.h"

namespace Ultima {
namespace Ultima3 {
namespace Gfx {

// How far sideways each of the places in view is from the party, before the facing is applied
static const byte CELL_DX[32] = {
	0x00, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
	0x01, 0x02, 0xFE, 0xFF, 0x00, 0x01, 0x02, 0xFD,
	0xFE, 0xFF, 0x01, 0x02, 0x03, 0xFD, 0xFE, 0xFF,
	0x00, 0x01, 0x02, 0x03, 0xFE, 0xFF, 0x01, 0x02
};

// How far ahead each place in view is
static const byte CELL_DY[32] = {
	0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
	0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
	0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFD, 0xFD, 0xFD,
	0xFD, 0xFD, 0xFD, 0xFD, 0xFD, 0xFD, 0xFD, 0xFD
};

// Where the lines of a ladder hole are drawn for each place
static const byte LADDERS[21][8] = {
	{ 0x30, 0x50, 0x10, 0x10, 0x20, 0x34, 0x4C, 0x60 },
	{ 0x00, 0x10, 0x00, 0x10, 0x20, 0x34, 0x4C, 0x60 },
	{ 0x70, 0x80, 0x10, 0x00, 0x20, 0x34, 0x4C, 0x60 },
	{ 0x18, 0x20, 0x28, 0x00, 0x30, 0x3A, 0x46, 0x50 },
	{ 0x38, 0x48, 0x28, 0x28, 0x30, 0x3A, 0x46, 0x50 },
	{ 0x60, 0x68, 0x00, 0x28, 0x30, 0x3A, 0x46, 0x50 },
	{ 0x00, 0x08, 0x00, 0x28, 0x30, 0x3A, 0x46, 0x50 },
	{ 0x20, 0x28, 0x00, 0x28, 0x30, 0x3A, 0x46, 0x50 },
	{ 0x58, 0x60, 0x28, 0x00, 0x30, 0x3A, 0x46, 0x50 },
	{ 0x78, 0x80, 0x28, 0x00, 0x30, 0x3A, 0x46, 0x50 },
	{ 0x1C, 0x20, 0x34, 0x00, 0x38, 0x3D, 0x42, 0x48 },
	{ 0x2C, 0x30, 0x34, 0x00, 0x38, 0x3D, 0x42, 0x48 },
	{ 0x3C, 0x44, 0x34, 0x34, 0x38, 0x3D, 0x42, 0x48 },
	{ 0x50, 0x54, 0x00, 0x34, 0x38, 0x3D, 0x42, 0x48 },
	{ 0x60, 0x64, 0x00, 0x34, 0x38, 0x3D, 0x42, 0x48 },
	{ 0x00, 0x04, 0x00, 0x34, 0x38, 0x3D, 0x42, 0x48 },
	{ 0x20, 0x24, 0x00, 0x34, 0x38, 0x3D, 0x42, 0x48 },
	{ 0x30, 0x34, 0x00, 0x34, 0x38, 0x3D, 0x42, 0x48 },
	{ 0x4C, 0x50, 0x34, 0x00, 0x38, 0x3D, 0x42, 0x48 },
	{ 0x5C, 0x60, 0x34, 0x00, 0x38, 0x3D, 0x42, 0x48 },
	{ 0x7C, 0x80, 0x34, 0x00, 0x38, 0x3D, 0x42, 0x48 }
};

// The extent of a chest drawn in each place
static const byte CHESTS[21][4] = {
	{ 0x30, 0x50, 0x68, 0x78 },
	{ 0x00, 0x10, 0x68, 0x78 },
	{ 0x70, 0x80, 0x68, 0x78 },
	{ 0x18, 0x20, 0x54, 0x5C },
	{ 0x38, 0x48, 0x54, 0x5C },
	{ 0x60, 0x68, 0x54, 0x5C },
	{ 0x00, 0x08, 0x54, 0x5C },
	{ 0x20, 0x28, 0x54, 0x5C },
	{ 0x58, 0x60, 0x54, 0x5C },
	{ 0x78, 0x80, 0x54, 0x5C },
	{ 0x1C, 0x20, 0x4A, 0x4E },
	{ 0x2C, 0x30, 0x4A, 0x4E },
	{ 0x3C, 0x44, 0x4A, 0x4E },
	{ 0x50, 0x54, 0x4A, 0x4E },
	{ 0x60, 0x64, 0x4A, 0x4E },
	{ 0x0C, 0x14, 0x4A, 0x4E },
	{ 0x20, 0x24, 0x4A, 0x4E },
	{ 0x30, 0x34, 0x4A, 0x4E },
	{ 0x4C, 0x50, 0x4A, 0x4E },
	{ 0x5C, 0x60, 0x4A, 0x4E },
	{ 0x6C, 0x74, 0x4A, 0x4E }
};

// The wall faces seen from each place, the second half being the parts cut away by doors
static const byte WALLS[64][8] = {
	{ 0x00, 0x00, 0x80, 0x02, 0xFF, 0xFF, 0x41, 0x00 },
	{ 0x01, 0x00, 0x80, 0x02, 0x01, 0x01, 0x10, 0x00 },
	{ 0x7F, 0x00, 0x80, 0xFE, 0x01, 0x01, 0x10, 0x00 },
	{ 0x00, 0x20, 0x60, 0x02, 0xFF, 0xFF, 0x10, 0x00 },
	{ 0x20, 0x20, 0x60, 0x02, 0xFF, 0xFF, 0x21, 0x00 },
	{ 0x80, 0x20, 0x60, 0xFE, 0xFF, 0xFF, 0x10, 0x00 },
	{ 0x01, 0x20, 0x60, 0x02, 0x02, 0x02, 0x10, 0x00 },
	{ 0x21, 0x20, 0x60, 0x02, 0x01, 0x01, 0x08, 0x00 },
	{ 0x5F, 0x20, 0x60, 0xFE, 0x01, 0x01, 0x08, 0x00 },
	{ 0x7F, 0x20, 0x60, 0xFE, 0x02, 0x02, 0x10, 0x00 },
	{ 0x00, 0x30, 0x50, 0x02, 0xFF, 0xFF, 0x10, 0x00 },
	{ 0x20, 0x30, 0x50, 0x02, 0xFF, 0xFF, 0x08, 0x00 },
	{ 0x30, 0x30, 0x50, 0x02, 0xFF, 0xFF, 0x11, 0x00 },
	{ 0x60, 0x30, 0x50, 0xFE, 0xFF, 0xFF, 0x08, 0x00 },
	{ 0x80, 0x30, 0x50, 0xFE, 0xFF, 0xFF, 0x10, 0x00 },
	{ 0x01, 0x30, 0x50, 0x02, 0x04, 0x04, 0x10, 0x00 },
	{ 0x21, 0x30, 0x50, 0x02, 0x02, 0x02, 0x08, 0x00 },
	{ 0x31, 0x30, 0x50, 0x02, 0x01, 0x01, 0x04, 0x00 },
	{ 0x4F, 0x30, 0x50, 0xFE, 0x01, 0x01, 0x04, 0x00 },
	{ 0x5F, 0x30, 0x50, 0xFE, 0x02, 0x02, 0x08, 0x00 },
	{ 0x7F, 0x30, 0x50, 0xFE, 0x04, 0x04, 0x10, 0x00 },
	{ 0x00, 0x38, 0x48, 0x02, 0xFF, 0xFF, 0x10, 0x00 },
	{ 0x20, 0x38, 0x48, 0x02, 0xFF, 0xFF, 0x08, 0x00 },
	{ 0x30, 0x38, 0x48, 0x02, 0xFF, 0xFF, 0x04, 0x00 },
	{ 0x38, 0x38, 0x48, 0x02, 0xFF, 0xFF, 0x09, 0x00 },
	{ 0x50, 0x38, 0x48, 0xFE, 0xFF, 0xFF, 0x04, 0x00 },
	{ 0x60, 0x38, 0x48, 0xFE, 0xFF, 0xFF, 0x08, 0x00 },
	{ 0x80, 0x38, 0x48, 0xFE, 0xFF, 0xFF, 0x10, 0x00 },
	{ 0x31, 0x38, 0x48, 0x02, 0x02, 0x02, 0x04, 0x00 },
	{ 0x39, 0x38, 0x48, 0x02, 0x01, 0x01, 0x04, 0x00 },
	{ 0x47, 0x38, 0x48, 0xFE, 0x01, 0x01, 0x04, 0x00 },
	{ 0x4F, 0x38, 0x48, 0xFE, 0x02, 0x02, 0x04, 0x00 },
	{ 0x20, 0x20, 0x80, 0x02, 0xFF, 0xFF, 0x21, 0x00 },
	{ 0x02, 0x20, 0x80, 0x02, 0x02, 0x01, 0x08, 0x00 },
	{ 0x7E, 0x20, 0x80, 0xFE, 0x02, 0x01, 0x08, 0x00 },
	{ 0x01, 0x30, 0x60, 0x02, 0xFF, 0xFF, 0x08, 0x00 },
	{ 0x31, 0x30, 0x60, 0x02, 0xFF, 0xFF, 0x10, 0x00 },
	{ 0x7F, 0x30, 0x60, 0xFE, 0xFF, 0xFF, 0x08, 0x00 },
	{ 0x0C, 0x2E, 0x5B, 0x02, 0x04, 0x02, 0x06, 0x00 },
	{ 0x26, 0x2E, 0x5B, 0x02, 0x02, 0x01, 0x03, 0x00 },
	{ 0x5A, 0x2E, 0x5B, 0xFE, 0x02, 0x01, 0x03, 0x00 },
	{ 0x74, 0x2E, 0x5B, 0xFE, 0x04, 0x02, 0x06, 0x00 },
	{ 0x11, 0x38, 0x50, 0x02, 0xFF, 0xFF, 0x05, 0x00 },
	{ 0x23, 0x38, 0x50, 0x02, 0xFF, 0xFF, 0x05, 0x00 },
	{ 0x3B, 0x38, 0x50, 0x02, 0xFF, 0xFF, 0x06, 0x00 },
	{ 0x5D, 0x38, 0x50, 0xFE, 0xFF, 0xFF, 0x05, 0x00 },
	{ 0x6F, 0x38, 0x50, 0xFE, 0xFF, 0xFF, 0x05, 0x00 },
	{ 0x0E, 0x36, 0x4D, 0x02, 0x08, 0x04, 0x04, 0x00 },
	{ 0x26, 0x36, 0x4D, 0x02, 0x04, 0x02, 0x02, 0x00 },
	{ 0x34, 0x36, 0x4D, 0x02, 0x02, 0x01, 0x01, 0x00 },
	{ 0x4C, 0x36, 0x4D, 0xFE, 0x02, 0x01, 0x01, 0x00 },
	{ 0x5A, 0x36, 0x4D, 0xFE, 0x04, 0x02, 0x02, 0x00 },
	{ 0x72, 0x36, 0x4D, 0xFE, 0x08, 0x04, 0x04, 0x00 },
	{ 0x11, 0x3C, 0x48, 0x02, 0xFF, 0xFF, 0x03, 0x00 },
	{ 0x25, 0x3C, 0x48, 0x02, 0xFF, 0xFF, 0x03, 0x00 },
	{ 0x33, 0x3C, 0x48, 0x02, 0xFF, 0xFF, 0x03, 0x00 },
	{ 0x3D, 0x3C, 0x48, 0x02, 0xFF, 0xFF, 0x04, 0x00 },
	{ 0x4D, 0x3C, 0x48, 0xFE, 0xFF, 0xFF, 0x03, 0x00 },
	{ 0x5B, 0x3C, 0x48, 0xFE, 0xFF, 0xFF, 0x03, 0x00 },
	{ 0x7F, 0x3C, 0x48, 0xFE, 0xFF, 0xFF, 0x03, 0x00 },
	{ 0x34, 0x3F, 0x46, 0x02, 0x01, 0x02, 0x01, 0x00 },
	{ 0x3C, 0x3F, 0x46, 0x02, 0x01, 0x01, 0x01, 0x00 },
	{ 0x44, 0x3F, 0x46, 0xFE, 0x01, 0x01, 0x01, 0x00 },
	{ 0x4C, 0x3F, 0x46, 0xFE, 0x01, 0x02, 0x01, 0x00 }
};

constexpr int LADDER_PLACES = 21;
constexpr int MIDDLE = 0x40;
constexpr int DOOR_CUTOUT = 0x20;

void DungeonView::plot(int x, int y) {
	x = (byte)(x + OFFSET);
	y = (byte)(y + OFFSET);

	if (y < HEIGHT)
		_pixels[y * WIDTH + x] = 3;
}

void DungeonView::column(int x, int top, int bottom, bool erase) {
	x = (byte)(x + OFFSET);
	int height = (byte)(bottom - top);

	// Hatched walls are made of columns of pixels, which this fills in or clears
	for (int y = (byte)top + OFFSET; height > 0 && y < HEIGHT; ++y, --height)
		_pixels[y * WIDTH + x] = erase ? 0 : 3;
}

void DungeonView::line(int x0, int y0, int x1, int y1) {
	int dx = ABS(x1 - x0), dy = ABS(y1 - y0);
	int stepX = (x1 < x0) ? -1 : 1;
	int stepY = (y1 < y0) ? -1 : 1;
	int x = x0, y = y0;

	if (dx >= dy) {
		int error = dx / 2;

		for (int count = dx; count > 0; --count) {
			error += dy;
			if (error >= dx) {
				error -= dx;
				y += stepY;
			}

			x += stepX;
			plot(x, y);
		}
	} else {
		int error = dy / 2;

		for (int count = dy; count > 0; --count) {
			error += dx;
			if (error >= dy) {
				error -= dy;
				x += stepX;
			}

			y += stepY;
			plot(x, y);
		}
	}
}

void DungeonView::drawWall(int face) {
	const byte *rec = WALLS[face];
	int x = rec[0], top = rec[1], bottom = rec[2];
	const int8 stepX = (int8)rec[3];
	const bool erase = face == DOOR_CUTOUT;

	// The slope of each edge is a number of columns for every row it drops
	int topCount = rec[4], bottomCount = rec[5];
	int columns = rec[6];

	// Walls seen side-on are shifted a column so their hatching lines up
	if (_facing & 1)
		x = (byte)(x + 1);

	auto slope = [&]() {
		topCount = (byte)(topCount - 1);
		if (topCount == 0) {
			topCount = rec[4];
			top = (byte)(top + 1);
		}

		bottomCount = (byte)(bottomCount - 1);
		if (bottomCount == 0) {
			bottomCount = rec[5];
			bottom = (byte)(bottom - 1);
		}
	};

	for (;;) {
		column(x, top, bottom, erase);
		if (--columns == 0)
			break;

		x = (byte)(x + stepX);
		slope();
		if (stepX != 1)
			slope();
	}
}

void DungeonView::drawLadder(bool down, int place) {
	if (place >= LADDER_PLACES)
		return;

	const byte *rec = LADDERS[place];
	if (rec[0] & 0x80)
		return;

	// A ladder going down is seen from the other side, so upside down
	auto at = [&](int value) { return down ? 0x7F - value : value; };

	int left = rec[0], right = rec[1];

	if (rec[2] != 0) {
		line(left, at(rec[2]), left, MIDDLE);
		line(left + 1, at(rec[2]), left + 1, MIDDLE);
	}
	if (rec[3] != 0) {
		line(right, at(rec[3]), right, MIDDLE);
		line(right - 1, at(rec[3]), right - 1, MIDDLE);
	}

	line(left, at(rec[4]), right, at(rec[4]));
	line(left, at(rec[5]), right, at(rec[5]));
}

void DungeonView::drawChest(int place) {
	if (place >= LADDER_PLACES)
		return;

	const byte *rec = CHESTS[place];
	if (rec[0] & 0x80)
		return;

	int x = rec[0];
	do {
		column(x, rec[2], rec[3], false);
		++x;
	} while (x < rec[1]);
}

DungeonView::Sight DungeonView::look(const Data::Dungeon &dungeon, int level, int x, int y, int place) {
	int dx = (int8)CELL_DX[place], dy = (int8)CELL_DY[place];

	// The places are laid out for looking north, so turn them to match
	for (int turns = _facing; turns > 0; --turns) {
		SWAP(dx, dy);
		dx = -dx;
	}

	byte tile = dungeon.tile(level, x + dx, y + dy);

	if (!(tile & Data::DTILE_WALL)) {
		if (tile & Data::DTILE_LADDER_UP)
			drawLadder(false, place);
		if (tile & Data::DTILE_LADDER_DOWN)
			drawLadder(true, place);
		if (tile & Data::DTILE_CHEST)
			drawChest(place);
		return OPEN;
	}

	drawWall(place);
	if (tile < Data::DTILE_DOOR)
		return WALL;

	// A door has the opening cut out of the wall
	drawWall(place + DOOR_CUTOUT);
	return place == 0 ? DOOR : WALL;
}

void DungeonView::lookAlong(const Data::Dungeon &dungeon, int level, int x, int y, const byte *places, int count) {
	for (int i = 0; i < count; ++i) {
		if (look(dungeon, level, x, y, places[i]) == WALL)
			return;
	}
}

void DungeonView::draw(const Data::Dungeon &dungeon, int level, int x, int y, int facing) {
	static const byte LEFT_A[] = { 1, 3, 6, 10, 15, 21 };
	static const byte RIGHT_A[] = { 2, 5, 9, 14, 20, 27 };
	static const byte LEFT_B[] = { 7, 11, 16, 22 };
	static const byte RIGHT_B[] = { 8, 13, 19, 26 };
	static const byte LEFT_C[] = { 17, 23, 28 };
	static const byte RIGHT_C[] = { 18, 25, 31 };

	memset(_pixels, 0, sizeof(_pixels));
	_facing = facing;

	// Working outwards from the party's own square, each line of sight is
	// followed until it meets a wall
	Sight here = look(dungeon, level, x, y, 0);
	if (here == WALL)
		return;

	if (here == OPEN) {
		lookAlong(dungeon, level, x, y, LEFT_A, ARRAYSIZE(LEFT_A));
		lookAlong(dungeon, level, x, y, RIGHT_A, ARRAYSIZE(RIGHT_A));
	}

	if (look(dungeon, level, x, y, 4) != OPEN)
		return;

	lookAlong(dungeon, level, x, y, LEFT_B, ARRAYSIZE(LEFT_B));
	lookAlong(dungeon, level, x, y, RIGHT_B, ARRAYSIZE(RIGHT_B));

	if (look(dungeon, level, x, y, 12) != OPEN)
		return;

	lookAlong(dungeon, level, x, y, LEFT_C, ARRAYSIZE(LEFT_C));
	lookAlong(dungeon, level, x, y, RIGHT_C, ARRAYSIZE(RIGHT_C));

	if (look(dungeon, level, x, y, 24) == WALL)
		return;

	look(dungeon, level, x, y, 29);
	look(dungeon, level, x, y, 30);
}

} // namespace Gfx
} // namespace Ultima3
} // namespace Ultima
