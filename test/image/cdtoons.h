/* ScummVM - Graphic Adventure Engine
 *
 * ScummVM is the legal property of its developers, whose names
 * are too numerous to list here. Please refer to the COPYRIGHT
 * file distributed with this source distribution.
 *
 * This program is free software: you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation, either version 3 of the License, or
 * (at your option) any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 *
 */

#include <cxxtest/TestSuite.h>

#include "common/memstream.h"
#include "graphics/surface.h"
#include "image/codecs/cdtoons.h"

class CDToonsDecoderTestSuite : public CxxTest::TestSuite {
public:
	void test_diff_entry_uses_its_declared_bounds() {
		const byte frame[] = {
			// Header with no cached blocks or actions and a full-surface dirty area.
			0x00, 0x09, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x02,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x02,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2c,
			0x00, 0x00, 0x00, 0x0a, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00,
			// One 24-byte Diff entry: rectangle, size, dimensions, reserved words,
			// and a two-pixel repeated RLE run.
			'D', 'i', 'f', 'f', 0x00, 0x00, 0x00, 0x2a,
			0x00, 0x01,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x02,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x02,
			0x00, 0x00, 0x00, 0x18,
			0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x02, 0x81, 0x33
		};

		Image::CDToonsDecoder decoder(2, 1);
		Common::MemoryReadStream stream(frame, sizeof(frame));
		const Graphics::Surface *surface = decoder.decodeFrame(stream);

		TS_ASSERT(surface != nullptr);
		TS_ASSERT_EQUALS(stream.pos(), static_cast<int64>(sizeof(frame)));
		if (!surface)
			return;

		const byte *pixels = static_cast<const byte *>(surface->getPixels());
		TS_ASSERT_EQUALS(pixels[0], 0x33);
		TS_ASSERT_EQUALS(pixels[1], 0x33);
	}

	void test_decode_frame_with_ignored_marker() {
		const byte frame[] = {
			// Frame header with one background-clearing action.
			0x00, 0x09, 0x00, 0x01, 0x00, 0x01, 0x00, 0x2a,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x02,
			0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x36,
			0x00, 0x00, 0x01, 0x0a, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00,
			// Clear with the frame background color, covering the 2x2 surface.
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
			0x00, 0x02,
			// Exact opaque, non-rendering Mrks entry shape from a real stream.
			'M', 'r', 'k', 's', 0x00, 0x00, 0x00, 0x22, 0x00, 0x01,
			0xe6, 0x68, 0xff, 0xff, 0x00, 0x00, 0x00, 0x18,
			0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x69, 0x53,
			0x74, 0x61, 0x02, 0x3e, 0xe3, 0xe0, 0x6b, 0x00
		};

		Image::CDToonsDecoder decoder(2, 2);
		Common::MemoryReadStream stream(frame, sizeof(frame));
		const Graphics::Surface *surface = decoder.decodeFrame(stream);

		TS_ASSERT(surface != nullptr);
		TS_ASSERT_EQUALS(stream.pos(), static_cast<int64>(sizeof(frame)));
		if (!surface)
			return;

		const byte *pixels = static_cast<const byte *>(surface->getPixels());
		for (uint y = 0; y < 2; y++) {
			for (uint x = 0; x < 2; x++)
				TS_ASSERT_EQUALS(pixels[y * surface->pitch + x], 0x2a);
		}
	}

	void test_xfrm_retains_background_action_range() {
		const byte firstFrame[] = {
			// Header: two image blocks and three actions, with a full-frame dirty rectangle.
			0x00, 0x09, 0x00, 0x01, 0x00, 0x01, 0x00, 0x05,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x02,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x02,
			0x00, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x4a,
			0x00, 0x02, 0x03, 0x0a, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00,
			// Action 0 is empty. Action 1 is the retained background; action 2 is foreground.
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00,
			0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
			0x00, 0x02,
			0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01,
			0x00, 0x02,
			// Block 1: a two-pixel background row containing color 0x11.
			0x00, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0x21,
			0x00, 0x01, 0xff, 0xff, 0x01, 0x00,
			0x00, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x03, 0x01, 0x11, 0x11,
			// Block 2: a one-pixel foreground row containing color 0x22.
			0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
			0x00, 0x01, 0xff, 0xff, 0x02, 0x00,
			0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x02, 0x00, 0x22,
			// XFrm selects action 1 (encoded start 2, count 1) for the backing layer.
			'X', 'F', 'r', 'm', 0x00, 0x00, 0x00, 0x1a,
			0x02, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
			0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00
		};
		const byte secondFrame[] = {
			// The next frame performs a transparent background update without clearing.
			0x00, 0x09, 0x00, 0x02, 0x00, 0x02, 0x00, 0x05,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x02,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x02,
			0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0x00, 0x4a,
			0x00, 0x03, 0x03, 0x0a, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00,
			0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
			0x00, 0x02,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00,
			// Block 3: two transparent pixels.
			0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
			0x00, 0x02, 0xff, 0xff, 0x01, 0x00,
			0x00, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x02, 0x81, 0x00,
			'X', 'F', 'r', 'm', 0x00, 0x00, 0x00, 0x1a,
			0x02, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
			0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
			0x00, 0x00,
			'B', 'c', 'k', 'R', 0x00, 0x00, 0x00, 0x12,
			0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
			0x00, 0x02,
			// Opaque extension chunks are accepted by size and do not affect composition.
			'S', 'c', 'a', 'l', 0x00, 0x00, 0x00, 0x0c,
			0xde, 0xad, 0xbe, 0xef,
			'W', 'r', 'M', 'p', 0x00, 0x00, 0x00, 0x0a,
			0xaa, 0x55
		};

		Image::CDToonsDecoder decoder(2, 1);
		Common::MemoryReadStream firstStream(firstFrame, sizeof(firstFrame));
		const Graphics::Surface *surface = decoder.decodeFrame(firstStream);
		TS_ASSERT(surface != nullptr);
		TS_ASSERT_EQUALS(firstStream.pos(), static_cast<int64>(sizeof(firstFrame)));
		if (!surface)
			return;

		const byte *pixels = static_cast<const byte *>(surface->getPixels());
		TS_ASSERT_EQUALS(pixels[0], 0x11);
		TS_ASSERT_EQUALS(pixels[1], 0x22);

		Common::MemoryReadStream secondStream(secondFrame, sizeof(secondFrame));
		surface = decoder.decodeFrame(secondStream);
		TS_ASSERT(surface != nullptr);
		TS_ASSERT_EQUALS(secondStream.pos(), static_cast<int64>(sizeof(secondFrame)));
		if (!surface)
			return;

		pixels = static_cast<const byte *>(surface->getPixels());
		TS_ASSERT_EQUALS(pixels[0], 0x11);
		TS_ASSERT_EQUALS(pixels[1], 0x11);
	}
};
